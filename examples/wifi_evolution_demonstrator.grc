options:
  parameters:
    author: GNU Radio / gr-ieee80211
    category: '[WiFi Demonstrators]'
    comment: |-
      Complete demonstration of WiFi PHY evolution from 802.11b (1 Mbps) to 802.11ac (866 Mbps)

      Features:
      - Multi-standard support: 802.11b/a/g/n/ac
      - Real-time statistics and visualization
      - Interactive rate control
      - Channel quality monitoring
      - USRP or loopback operation
    description: WiFi Evolution Demonstrator - All Standards (802.11b/a/g/n/ac)
    generate_options: qt_gui
    hier_block_src_path: .:.
    id: wifi_evolution_demonstrator
    output_language: python
    title: WiFi Evolution Demonstrator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 11e6
  states: {}
- name: wifi_standard
  id: variable_qtgui_chooser
  parameters:
    comment: Select WiFi standard
    gui_hint: 0,0,1,2
    label: WiFi Standard
    label0: 802.11b DSSS/CCK
    label1: 802.11a/g OFDM
    label2: 802.11n HT
    label3: 802.11ac VHT
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: dsss_rate
  id: variable_qtgui_chooser
  parameters:
    comment: 802.11b rate selection
    gui_hint: 1,0,1,2
    label: 802.11b Rate
    label0: 1 Mbps Long
    label1: 2 Mbps Long
    label2: 5.5 Mbps Long
    label3: 11 Mbps Long
    label4: 2 Mbps Short
    label5: 5.5 Mbps Short
    label6: 11 Mbps Short
    num_opts: '7'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    option5: '5'
    option6: '6'
    options: '[0, 1, 2, 3, 4, 5, 6]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: ofdm_rate
  id: variable_qtgui_chooser
  parameters:
    comment: 802.11a/g rate selection
    gui_hint: 2,0,1,2
    label: 802.11a/g Rate
    label0: 6 Mbps (BPSK 1/2)
    label1: 9 Mbps (BPSK 3/4)
    label2: 12 Mbps (QPSK 1/2)
    label3: 18 Mbps (QPSK 3/4)
    label4: 24 Mbps (16-QAM 1/2)
    label5: 36 Mbps (16-QAM 3/4)
    label6: 48 Mbps (64-QAM 2/3)
    label7: 54 Mbps (64-QAM 3/4)
    num_opts: '8'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    option5: '5'
    option6: '6'
    option7: '7'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: WiFi frequency (2.4 GHz / 5 GHz bands)
    gui_hint: 3,0,1,2
    label: Center Frequency (Hz)
    start: 2.4e9
    step: 5e6
    stop: 5.9e9
    value: 2.437e9
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: TX Gain (dB)
    min_len: '100'
    start: '0'
    step: '1'
    stop: '89'
    value: '20'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: RX Gain (dB)
    min_len: '100'
    start: '0'
    step: '1'
    stop: '76'
    value: '20'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    comment: Channel noise level
    gui_hint: 5,0,1,2
    label: Noise Level
    min_len: '100'
    start: '0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: DSSS correlation threshold
    gui_hint: 5,2,1,2
    label: Correlation Threshold
    min_len: '100'
    start: '0.5'
    step: '0.1'
    stop: '11.0'
    value: '2.3'
  states: {}
- name: enable_tx
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 6,0,1,1
    label: Enable TX
    'true': '1'
    type: int
    value: 'True'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: Packet generator
    msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(packet_len, 0x42))
    period: '100'
  states: {}
- name: ieee80211_ppdu_prefixer_0
  id: ieee80211_ppdu_prefixer
  parameters:
    comment: DSSS/CCK preamble and header
    rate: dsss_rate
  states: {}
- name: ieee80211_ppdu_chip_mapper_bc_0
  id: ieee80211_ppdu_chip_mapper_bc
  parameters:
    comment: DSSS/CCK chip mapper
    length_tag_name: packet_len
  states: {}
- name: ieee80211_encode_0
  id: ieee80211_encode
  parameters:
    comment: OFDM encoder
    debug: 'False'
  states: {}
- name: ieee80211_modulation_0
  id: ieee80211_modulation
  parameters:
    comment: OFDM modulation
    debug: 'False'
    samp_rate: samp_rate
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: Select TX path based on standard
    enabled: 'True'
    input_index: wifi_standard
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_voltage
    comment: AWGN channel noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Add noise to signal
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Multipath fading
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '42'
    taps: 1.0 + 0.0j
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    comment: Select RX path based on standard
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: wifi_standard
    type: complex
  states: {}
- name: ieee80211_chip_sync_c_0
  id: ieee80211_chip_sync_c
  parameters:
    comment: DSSS receiver
    long_preamble: dsss_rate < 4
    threshold: threshold
  states: {}
- name: ieee80211_sync_short_0
  id: ieee80211_sync_short
  parameters:
    comment: OFDM sync
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: ieee80211_demod_0
  id: ieee80211_demod
  parameters:
    comment: OFDM demodulation
    debug: 'False'
    log: 'False'
    samp_rate: samp_rate
  states: {}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters:
    comment: OFDM decoder
    debug: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: RX packet debug
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    comment: OFDM packet debug
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: TX Signal Visualization
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 7,0,4,2
    label1: I
    label2: Q
    name: TX Signal
    size: '2048'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: RX Signal Visualization
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 7,2,4,2
    label1: I
    label2: Q
    name: RX Signal
    size: '2048'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Spectrum Analyzer
    ctrlpanel: 'True'
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 11,0,4,4
    label1: TX Spectrum
    label2: RX Spectrum
    name: Spectrum Analyzer
    nconnections: '2'
    type: complex
  states: {}

connections:
- [blocks_message_strobe_0, strobe, ieee80211_ppdu_prefixer_0, in]
- [ieee80211_ppdu_prefixer_0, '0', ieee80211_ppdu_chip_mapper_bc_0, '0']
- [ieee80211_ppdu_chip_mapper_bc_0, '0', blocks_selector_0, '0']
- [blocks_message_strobe_0, strobe, ieee80211_encode_0, app in]
- [ieee80211_encode_0, '0', ieee80211_modulation_0, '0']
- [ieee80211_modulation_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', blocks_add_xx_0, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', blocks_selector_1, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_1, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_selector_1, '0', ieee80211_chip_sync_c_0, '0']
- [ieee80211_chip_sync_c_0, out, blocks_message_debug_0, print]
- [blocks_selector_1, '1', ieee80211_sync_short_0, '0']
- [ieee80211_sync_short_0, '0', ieee80211_demod_0, '0']
- [ieee80211_demod_0, out, ieee80211_decode_0, in]
- [ieee80211_decode_0, out, blocks_message_debug_1, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
