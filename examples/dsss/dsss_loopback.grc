options:
  parameters:
    author: gr-ieee80211
    description: 802.11b DSSS Loopback Test - All 7 Rates
    generate_options: qt_gui
    id: dsss_loopback
    output_language: python
    title: 802.11b DSSS Loopback Test
  states: {}

blocks:
- name: rate
  id: variable
  parameters:
    comment: |-
      0=1M long, 1=2M long, 2=5.5M long, 3=11M long,
      4=2M short, 5=5.5M short, 6=11M short
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 11e6
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '2.3'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: |-
      Generate test packets
      (100 bytes of 0x42)
    msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(packet_len, 0x42))
    period: '100'
  states: {}
- name: ieee80211_ppdu_prefixer
  id: ieee80211_ppdu_prefixer
  parameters:
    comment: |-
      Add PLCP preamble
      and header
    rate: rate
  states: {}
- name: ieee80211_ppdu_chip_mapper_bc
  id: ieee80211_ppdu_chip_mapper_bc
  parameters:
    comment: |-
      Map to DSSS/CCK
      chips
    length_tag_name: packet_len
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Attenuation
    const: '0.5'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_voltage
    comment: |-
      Channel noise
      (adjustable)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Add noise to signal
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: TX Signal Viewer
    label1: I
    label2: Q
    size: '2200'
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: ieee80211_chip_sync_c
  id: ieee80211_chip_sync_c
  parameters:
    comment: |-
      DSSS receiver
      and demodulator
    long_preamble: rate < 4
    threshold: threshold
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Display RX packets
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', ieee80211_chip_sync_c, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, ieee80211_ppdu_prefixer, psdu_in]
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [ieee80211_chip_sync_c, psdu_out, blocks_message_debug_0, print]
- [ieee80211_ppdu_chip_mapper_bc, '0', blocks_multiply_const_vxx_0, '0']
- [ieee80211_ppdu_prefixer, ppdu_out, ieee80211_ppdu_chip_mapper_bc, in]

metadata:
  file_format: 1
  grc_version: 3.10.1.1
