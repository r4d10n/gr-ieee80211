options:
  parameters:
    author: gr-ieee80211
    description: USRP 802.11b DSSS Transceiver
    generate_options: qt_gui
    id: usrp_dsss_transceiver
    output_language: python
    title: USRP 802.11b DSSS Transceiver
  states: {}

blocks:
- name: rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Data Rate
    label0: 1 Mbps Long
    label1: 2 Mbps Long
    label2: 5.5 Mbps Long
    label3: 11 Mbps Long
    label4: 2 Mbps Short
    labels: [5.5 Mbps Short, 11 Mbps Short, '', '', '']
    num_opts: '7'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    options: ['5', '6', '', '', '']
    type: int
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 11e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Center Frequency
    start: 2.4e9
    step: 1e6
    stop: 2.5e9
    value: 2.437e9
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: TX Gain
    start: '0'
    step: '1'
    stop: '89'
    value: '30'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: RX Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '40'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Correlation Threshold
    start: '0.5'
    step: '0.1'
    stop: '11.0'
    value: '2.3'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,1,1,1
    label: Enable TX
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: |-
      TX Packet Generator
      (10 packets/sec)
    msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(packet_len, 0x42))
    period: '100'
  states: {}
- name: ieee80211_ppdu_prefixer
  id: ieee80211_ppdu_prefixer
  parameters:
    rate: rate
  states: {}
- name: ieee80211_ppdu_chip_mapper_bc
  id: ieee80211_ppdu_chip_mapper_bc
  parameters:
    length_tag_name: packet_len
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: |-
      TX Enable
      Switch
    enabled: 'True'
    input_index: tx_enable
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    comment: |-
      USRP Transmitter
      (Channel 6: 2.437 GHz)
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    comment: |-
      USRP Receiver
      (Channel 6: 2.437 GHz)
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: ieee80211_chip_sync_c
  id: ieee80211_chip_sync_c
  parameters:
    comment: |-
      DSSS Receiver
      and Demodulator
    long_preamble: rate < 4
    threshold: threshold
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,0,1,2
    label1: I
    label2: Q
    name: RX Signal
    size: '4400'
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: RX Packet Display
  states: {}

connections:
- [blocks_message_strobe_0, strobe, ieee80211_ppdu_prefixer, psdu_in]
- [blocks_null_source_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', uhd_usrp_sink_0, '0']
- [ieee80211_chip_sync_c, psdu_out, blocks_message_debug_0, print]
- [ieee80211_ppdu_chip_mapper_bc, '0', blocks_selector_0, '0']
- [ieee80211_ppdu_prefixer, ppdu_out, ieee80211_ppdu_chip_mapper_bc, in]
- [uhd_usrp_source_0, '0', ieee80211_chip_sync_c, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.1.1
